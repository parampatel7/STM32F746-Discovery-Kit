# file: adc_interrupt_eoc.ioc
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Mcu.Family=STM32F7
Mcu.Name=STM32F746NGHx
Mcu.Package=TFBGA216
NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
ProjectManager.HeapSize=0x200
ProjectManager.StackSize=0x400
ProjectManager.TargetToolchain=STM32CubeIDE
RCC.AHBFreq_Value=216000000
RCC.APB1CLKDivider=RCC_HCLK_DIV4
RCC.APB1Freq_Value=54000000
RCC.APB1TimFreq_Value=108000000
RCC.APB2CLKDivider=RCC_HCLK_DIV2
RCC.APB2Freq_Value=108000000
RCC.APB2TimFreq_Value=216000000
RCC.CortexFreq_Value=216000000
RCC.HCLKFreq_Value=216000000
RCC.HSE_VALUE=25000000
RCC.HSI_VALUE=16000000
RCC.LSE_VALUE=32768
RCC.PLL48CLockSelection=RCC_CLK48SOURCE_PLLSAIP
RCC.PLLI2SN=100
RCC.PLLM=8
RCC.PLLN=216
RCC.PLLQ=9
RCC.PLLSAIN=384
RCC.PLLSAIP=RCC_PLLSAIP_DIV8
RCC.PLLSAIR=5
RCC.PLLSAIRDiv=RCC_PLLSAIDIVR_8
RCC.SDMMCClockSelection=RCC_SDMMC1CLKSOURCE_CLK48
RCC.SYSCLKFreq_VALUE=216000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
RCC.USBFreq_Value=96000000
RCC.VCOOutputFreq_Value=432000000
board=STM32F746G-DISCO

// file: Core/Src/main.c
/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.c
  * @brief          : Main program body
  ******************************************************************************
  * @attention
  *
  * Copyright (c) 2025 STMicroelectronics.
  * All rights reserved.
  *
  * This software is licensed under terms that can be found in the LICENSE file
  * in the root directory of this software component.
  * If no LICENSE file comes with this software, it is provided AS-IS.
  *
  ******************************************************************************
  */
/* USER CODE END Header */
//<------------------------------------------------------------------------------->

//<------------------------------------------------------------------------------->
#include "main.h"
/*-------------------------------------------------------------*/
/* USER CODE BEGIN Includes */
#include "stm32f7xx.h"
/* USER CODE END Includes */

void SystemClock_Config(void);
/* USER CODE BEGIN PFP */
void gpio_init(void);
void adc_init(void);
uint32_t data;
uint16_t volts;
volatile uint8_t adc_conversion_complete = 0;
//char adc_conversion_complete=0;
/* USER CODE END PFP */

int main(void)
{

  /* MCU Configuration--------------------------------------------------------*/

  /* Reset of all peripherals, Initializes the Flash interface and the Systick. */
  HAL_Init();

  /* Configure the system clock */
  SystemClock_Config();

  /* USER CODE BEGIN SysInit */
  gpio_init();
  adc_init();
  /* USER CODE END SysInit */

  /* Initialize all configured peripherals */
  /* USER CODE BEGIN 2 */
  ADC1->CR2 |= ADC_CR2_ADON;
  adc_conversion_complete = 0;
  ADC1->CR2 |= ADC_CR2_SWSTART;//STARTS CONVERSION
  //HAL_Delay(500);
  	  //while(!adc_conversion_complete);
  /* USER CODE END 2 */

  /* Infinite loop */
  while (1)
  {
	 if (adc_conversion_complete ==1 )
	  {
		  volts = (data * 3300) / 4095;    // Convert to millivolts (assuming 3.3V ref)
	      for (int i = 0; i < 5; i++)
	         {
	  	          GPIOD->ODR ^= (1U << 6);
	  	          HAL_Delay(1000);
	  	      }

	  }
	  HAL_Delay(500);
  }
}

void ADC_IRQHandler(void)
{
    if (ADC1->SR & ADC_SR_EOC)
    {
        data = ADC1->DR & 0xFFF;  // Read 12-bit result
        ADC1->SR &= ~ADC_SR_EOC;  // Clear EOC flag
      //  ADC1->CR2 &= ~ADC_CR2_SWSTART;  // Stop conversion trigger<---------- cant be done by software, set/cleared by hardware
        ADC1->CR2 &= ~ADC_CR2_ADON;           // Disable ADC
        ADC1->CR1 &= ~ADC_CR1_EOCIE;		//disable interrupt so that doesnt trigger again
        adc_conversion_complete = 1U; // Signal to main loop
       // volts = (data * 3300) / 4095;    // Convert to millivolts (assuming 3.3V ref)
    }

    if (ADC1->SR & ADC_SR_OVR)
       {
           volatile uint32_t tmp = ADC1->DR; // Read DR to clear OVR
           (void)tmp;
           ADC1->SR &= ~ADC_SR_OVR;         // Clear the flag
       }
}
void adc_init(void)
{	ADC1->SR = 0;  // Clear all status flags
    RCC->APB2ENR |= RCC_APB2ENR_ADC1EN;
    RCC->AHB1ENR |= RCC_AHB1ENR_GPIOAEN;
    GPIOA->MODER |= (3U << (4 * 2)); // Analog mode for PA4

    ADC123_COMMON->CCR |= (1U << 16);  //PCLK DIVIDE BY 4
    ADC123_COMMON-> CCR |= (15U << 8); //DELAY BETWEEN 2 SAMPLING PHRASES
	ADC1->CR1 &= ~(3U << 24); //resolution 12bit
	ADC1->CR1 |= (1U << 8);   //scan mode enabled

	//ADC1->CR2 |= ADC_CR2_ALIGN; //LEFT ALIGN DATA, ADC result is placed in bits [15:4] of ADC1->DR for 12bit resolution
	ADC1->CR2 &= ~ADC_CR2_ALIGN;     // Right-align
 	ADC1->CR2 |= ADC_CR2_EOCS; // Enable EOC selection — interrupt after each conversion

//	ADC1->CR2 &= ~ADC_CR2_CONT; // Make sure it's single conversion mode
	ADC1->SMPR2 |= (7U << 12); //480 CHANNEL SAMPLING CYCLES SET, how long ADC samples input voltage before converting it
    ADC1->SQR3 = 4U;
    /*Because a conversion sequence can include up to 16 channels,
     * and each SQR register holds multiple 5-bit fields (each field represents a channel number), STM32 splits them:
SQR3: channels 1–6
SQR2: channels 7–12
SQR1: channels 13–16 + number of conversions
SQR registers configure the order of regular ADC conversions.
ADC1->SQR3 = 4U; sets channel 4 as the first to convert.*/

	ADC1->CR1 |= ADC_CR1_EOCIE; // Enable End of Conversion Interrupt
    NVIC_EnableIRQ(ADC_IRQn);    // Enable ADC interrupt in NVIC
    NVIC_SetPriority(ADC_IRQn, 1);
}
void gpio_init(void)
{
	RCC->AHB1ENR |= RCC_AHB1ENR_GPIOAEN ;
	GPIOA->MODER |= (3U << 8); // PA4 to analog mode
	RCC->AHB1ENR |= RCC_AHB1ENR_GPIODEN;

	// Set PD6 to general purpose output mode (MODER = 01)
	GPIOD->MODER &= ~(3U << (6 * 2)); // Clear bits
	GPIOD->MODER |=  (1U << (6 * 2)); // Set bit 12 to 1, bit 13 to 0

	// Optional: Set output type to push-pull (default)
	GPIOD->OTYPER &= ~(1U << 6);

	// Optional: Set output speed (e.g., high speed)
	GPIOD->OSPEEDR |= (3U << (6 * 2));

	// Optional: No pull-up/pull-down
	GPIOD->PUPDR &= ~(3U << (6 * 2));
}
void SystemClock_Config(void)
{
	RCC_OscInitTypeDef RCC_OscInitStruct = {0};
	  RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};

	  /** Configure the main internal regulator output voltage
	  */
	  __HAL_RCC_PWR_CLK_ENABLE();
	  __HAL_PWR_VOLTAGESCALING_CONFIG(PWR_REGULATOR_VOLTAGE_SCALE1);

	  /** Initializes the RCC Oscillators according to the specified parameters
	  * in the RCC_OscInitTypeDef structure.
	  */
	  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSE;
	  RCC_OscInitStruct.HSEState = RCC_HSE_ON;
	  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_ON;
	  RCC_OscInitStruct.PLL.PLLSource = RCC_PLLSOURCE_HSE;
	  RCC_OscInitStruct.PLL.PLLM = 25;
	  RCC_OscInitStruct.PLL.PLLN = 400;
	  RCC_OscInitStruct.PLL.PLLP = RCC_PLLP_DIV2;
	  RCC_OscInitStruct.PLL.PLLQ = 9;
	  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
	  {
	    Error_Handler();
	  }

	  /** Activate the Over-Drive mode
	  */
	  if (HAL_PWREx_EnableOverDrive() != HAL_OK)
	  {
	    Error_Handler();
	  }

	  /** Initializes the CPU, AHB and APB buses clocks
	  */
	  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
	                              |RCC_CLOCKTYPE_PCLK1|RCC_CLOCKTYPE_PCLK2;
	  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_PLLCLK;
	  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
	  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV4;
	  RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV2;

	  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_6) != HAL_OK)
	  {
	    Error_Handler();
	  }
}

void Error_Handler(void)
{
  __disable_irq();
  while (1)
  {
  }
}
