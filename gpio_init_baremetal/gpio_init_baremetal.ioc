# file: gpio_init_baremetal.ioc
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Mcu.Family=STM32F7
Mcu.Name=STM32F746NGHx
Mcu.Package=TFBGA216
NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
ProjectManager.HeapSize=0x200
ProjectManager.StackSize=0x400
ProjectManager.TargetToolchain=STM32CubeIDE
RCC.AHBFreq_Value=168000000
RCC.APB1CLKDivider=RCC_HCLK_DIV4
RCC.APB1Freq_Value=42000000
RCC.APB1TimFreq_Value=84000000
RCC.APB2CLKDivider=RCC_HCLK_DIV2
RCC.APB2Freq_Value=84000000
RCC.APB2TimFreq_Value=168000000
RCC.CortexFreq_Value=168000000
RCC.HCLKFreq_Value=168000000
RCC.HSE_VALUE=25000000
RCC.HSI_VALUE=16000000
RCC.LSE_VALUE=32768
RCC.PLLM=10
RCC.PLLN=210
RCC.PLLSourceVirtual=RCC_PLLSOURCE_HSI
RCC.SYSCLKFreq_VALUE=168000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
RCC.USBFreq_Value=168000000
RCC.VCOOutputFreq_Value=336000000
board=STM32F746G-DISCO

// file: Core/Src/main.c
/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.c
  * @brief          : Main program body
  ******************************************************************************
  * @attention
  *
  * Copyright (c) 2025 STMicroelectronics.
  * All rights reserved.
  *
  * This software is licensed under terms that can be found in the LICENSE file
  * in the root directory of this software component.
  * If no LICENSE file comes with this software, it is provided AS-IS.
  *
  ******************************************************************************
  */
/* USER CODE END Header */
#include "main.h"
#include "stm32f7xx.h"
/*USER PUSH BUTTON PRESS WILL TURN ON LED*/

void SystemClock_Config(void);
static void GPIO_Init(void);

int main(void)
{

  /* MCU Configuration--------------------------------------------------------*/

  /* Reset of all peripherals, Initializes the Flash interface and the Systick. */
  HAL_Init();

  /* Configure the system clock */
  SystemClock_Config();

  /* Initialize all configured peripherals */
  // Adjust if using a different CMSIS core header

    GPIO_Init();

    while (1) {
        /*if ((GPIOC->IDR & (1 << 13)) == 0) { // If button pressed (active low)
            GPIOA->ODR |= (1 << 5);          // Turn on LED (set PA5)
        } else {
            GPIOA->ODR &= ~(1 << 5);         // Turn off LED (reset PA5)
        }*/
//IDR is input data register, for PI11 we read 11th bit
    	uint32_t button_state = (GPIOI->IDR & (1U << 11)); //1U AS UNSIGNED, PLACING ONLY 1 IS INT AND CAN CAUSE SOME UNDEFINED BEHAVIOUR

    	        if (button_state)
    	        {//ODR is output data register, PD5 has LED
    	            // Button is high (not pressed if active-low)
    	            GPIOD->ODR &= ~(1U << 5);  // Turn off LED
    	        }
    	        else
    	        {
    	            // Button is low (pressed if active-low)
    	            GPIOD->ODR |= (1U << 5);   // Turn on LED
    	        }
    }
}
static void GPIO_Init(void) {
    // 1. Enable clock for GPIOA and GPIOC
    /*RCC->AHB1ENR |= (1 << 0);   // GPIOA clock enable
    RCC->AHB1ENR |= (1 << 2);   // GPIOC clock enable

    // 2. Configure PA5 as general purpose output
    GPIOA->MODER &= ~(3 << (5 * 2));  // Clear mode bits for PA5
    GPIOA->MODER |=  (1 << (5 * 2));  // Set mode to 01 (general purpose output)

    GPIOA->OTYPER &= ~(1 << 5);       // Set output type to push-pull
    GPIOA->OSPEEDR |= (3 << (5 * f2)); // High speed (optional)
    GPIOA->PUPDR &= ~(3 << (5 * 2));  // No pull-up, pull-down

    // 3. Configure PC13 as input
    GPIOC->MODER &= ~(3 << (13 * 2)); // Input mode (00)
    GPIOC->PUPDR &= ~(3 << (13 * 2)); // No pull-up, pull-down*/

	// Enable clocks for GPIOD and GPIOI
	    RCC->AHB1ENR |= RCC_AHB1ENR_GPIODEN | RCC_AHB1ENR_GPIOIEN;

	    // --- Configure PD5 (LED) ---
	     /*MODER5 = 00 (INPUT)
	    			01 (output)
	    			10 (ALTERNATE FUNCTION
	    			11 (ANALOG) */
	    GPIOD->MODER &= ~(3U << 10); //WE FIRST CLEAR ALL TWO BITS AND THEN SET THEM
	    GPIOD->MODER |=  (1U << 10);

	    // OTYPER5 = 0 (push-pull)
	    GPIOD->OTYPER &= ~(1U << 5);

	    // OSPEEDR5 = 10 (medium speed) or 11 (high speed)
	    GPIOD->OSPEEDR &= ~(3U << (5 * 2));
	    GPIOD->OSPEEDR |=  (2U << (5 * 2));  // Medium speed

	    // PUPDR5 = 00 (no pull-up/pull-down)
	    GPIOD->PUPDR &= ~(3U << 10);

	    // --- Configure PI11 (Button) ---
	    // MODER11 = 00 (input)
	    GPIOI->MODER &= ~(3U << 22);

	    // PUPDR11 = 01 (pull-up), assuming active-low button
	    /*  00	No Pull	Pin is floating (default)
			01	Pull-Up	Pin is pulled high, CONNECTED TO Vcc
			10	Pull-Down	Pin is pulled low, CONNECTED TO GROUND
			11	Reserved	Do not use*/
	    GPIOI->PUPDR &= ~(3U << 22);
	    GPIOI->PUPDR |=  (1U << 22);  // Enable pull-up

	    // OTYPER and OSPEEDR not needed for input pins
}

  /* Infinite loop */

void SystemClock_Config(void)
{
  RCC_OscInitTypeDef RCC_OscInitStruct = {0};
  RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};

  /** Configure the main internal regulator output voltage
  */
  __HAL_RCC_PWR_CLK_ENABLE();
  __HAL_PWR_VOLTAGESCALING_CONFIG(PWR_REGULATOR_VOLTAGE_SCALE1);

  /** Initializes the RCC Oscillators according to the specified parameters
  * in the RCC_OscInitTypeDef structure.
  */
  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSE;
  RCC_OscInitStruct.HSEState = RCC_HSE_ON;
  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_ON;
  RCC_OscInitStruct.PLL.PLLSource = RCC_PLLSOURCE_HSE;
  RCC_OscInitStruct.PLL.PLLM = 25;
  RCC_OscInitStruct.PLL.PLLN = 400;
  RCC_OscInitStruct.PLL.PLLP = RCC_PLLP_DIV2;
  RCC_OscInitStruct.PLL.PLLQ = 9;
  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
  {
    Error_Handler();
  }

  /** Activate the Over-Drive mode
  */
  if (HAL_PWREx_EnableOverDrive() != HAL_OK)
  {
    Error_Handler();
  }

  /** Initializes the CPU, AHB and APB buses clocks
  */
  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
                              |RCC_CLOCKTYPE_PCLK1|RCC_CLOCKTYPE_PCLK2;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_PLLCLK;
  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV4;
  RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV2;

  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_6) != HAL_OK)
  {
    Error_Handler();
  }
}

void Error_Handler(void)
{
  __disable_irq();
  while (1)
  {
  }
}
